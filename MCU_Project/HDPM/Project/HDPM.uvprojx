# Keil uVision project HDPM.uvprojx, settings and files
target HDPM (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HDPM +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\HARDWARE\max5742;..\HARDWARE\ADC;..\HARDWARE\charge;..\HARDWARE\GPIO;..\HARDWARE\KEY;..\HARDWARE\RNG;..\HARDWARE\TIMER;..\Common\usart;..\HARDWARE\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rng.c stm32f4xx_adc.c
  group Common
    ../Common/: common.c
    ../Common/usart/: usart.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/charge/: charge.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/max5742/: max5742.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2
